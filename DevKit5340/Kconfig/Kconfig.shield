## DevKit5340/Kconfig/Kconfig.sysbuild.modules
```kconfig
menu "nrf (C:/ncs/v2.6/nrf)"
osource "C:/ncs/v2.6/nrf/sysbuild/Kconfig.sysbuild"
config ZEPHYR_NRF_MODULE
	bool
	default y
endmenu
```
